Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: HCP30E52UC_TradeCAD.ifc
Time: 2022-02-14T14:26:03
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
HCP30E52UC_TradeCAD.dxf - ObjectType: SketchupComponentInstance

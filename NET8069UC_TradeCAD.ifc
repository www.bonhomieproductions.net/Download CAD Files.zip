Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: NET8069UC_TradeCAD.ifc
Time: 2022-02-15T15:02:17
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
NET8069UC_TradeCAD.dxf - ObjectType: SketchupComponentInstance

Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: NGM5058UC_TradeCAD.ifc
Time: 2021-12-03T10:20:17
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
NGM5058UC_TradeCAD_dxf - ObjectType: SketchupComponentInstance

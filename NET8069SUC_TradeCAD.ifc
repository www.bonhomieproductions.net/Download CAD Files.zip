Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: NETP069SUC_TradeCAD.ifc
Time: 2022-02-15T14:12:23
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
NETP069SUC_TradeCAD.dxf - ObjectType: SketchupComponentInstance

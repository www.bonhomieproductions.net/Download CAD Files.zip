Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: HIS8655C_TradeCAD.ifc
Time: 2022-01-21T13:40:21
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
HIS8055U_TRADECAD_DXF - ObjectType: SketchupComponentInstance

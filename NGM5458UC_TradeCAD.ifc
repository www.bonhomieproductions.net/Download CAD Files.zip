Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: NGM5458UC_TradeCAD.ifc
Time: 2021-12-02T22:39:19
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
NGM5458UC_TradeCAD.dxf - ObjectType: SketchupComponentInstance
